<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\CambienSTM8s.ewp</path>
    </project>
    <batchBuild />
</workspace>
